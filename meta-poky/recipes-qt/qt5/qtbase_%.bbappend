PACKAGECONFIG_append = " examples gles2 eglfs"
